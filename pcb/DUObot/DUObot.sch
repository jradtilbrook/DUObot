File: pcb/DUObot/DUObot.sch (EAGLE design)
At the start: 0 parts

Commit message: Update readme to reflect todo list
Parts:
- added MCU: ATMEGA2560AU, SparkFun-DigitalIC:ATMEGA2560AU
